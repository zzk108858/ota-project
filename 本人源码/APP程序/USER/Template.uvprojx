# Keil uVision project Template.uvprojx, settings and files
target Template (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  AfterMake: E:\keil5\Core\ARM\ARM_Compiler_5.06u7\bin\fromelf.exe --bin --output=..\OBJ\Template.bin ..\OBJ\Template.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\usart;..\SYSTEM\delay;..\HardWare\I2C;..\HardWare\AT24C02;..\HardWare\SPI;..\HardWare\W25Q64;..\HardWare\Board_Flash;..\HardWare\boot;..\HardWare\FS4G;..\HardWare\MQTT
  memory RVCT4: ROM 0x8005000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_dma.c stm32f10x_spi.c stm32f10x_flash.c stm32f10x_exti.c
  group SYSTEM
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/delay/: delay.c
  group Hardware
    ../HardWare/I2C/: iic.c
    ../HardWare/AT24C02/: AT24C02.c
    ../HardWare/SPI/: SPI.c
    ../HardWare/W25Q64/: W25Q64.c
    ../HardWare/Board_Flash/: Board_Flash.c
    ../HardWare/FS4G/: FS4G.c
    ../HardWare/MQTT/: MQTT.c
